# The Panfrost driver stack includes an OpenGL ES implementation for Arm Mali GPUs 
PACKAGECONFIG:append:seco-px30-d23 = " kmsro panfrost"
