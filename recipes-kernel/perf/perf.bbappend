EXTRA_OEMAKE += ' \
    EXTRA_CFLAGS+=" -Wno-error=stringop-truncation" \
'
PERF_SRC += " \
	include/ \
"
